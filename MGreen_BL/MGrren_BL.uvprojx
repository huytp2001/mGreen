# Keil uVision project MGrren_BL.uvprojx, settings and files
target MGreen_BL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C129ENCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MGreen_BL +hex
  AfterMake: fromelf --bin --output .\rvmdk\MGreen_BL.bin .\rvmdk\MGreen_BL.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C129ENCPDT TARGET_IS_TM4C129_RA0
  c misc: --c99
  c include: .\Inc;.\Library\Inc;.\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT6: RAM 0x60000000 size 0x2000000
  memory RVCT9: RAM 0x20000000 size 0x3ffdc
  memory RVCT10: RAM 0x2003ffdc size 0x24
  link misc: --entry Reset_Handler
  group Source
    ./Src/: MGreen_BL.c mmc-dk-tm4c129x.c simple_fs.c crc.c params.c sdram.c startup_rvmdk.S boot_config.c ff.c sd_card.c
    ./Inc/: boot_config.h
  group Libraries
    ./Library/: driverlib.lib usblib.lib
