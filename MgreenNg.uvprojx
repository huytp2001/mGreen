# Keil uVision project MgreenNg.uvprojx, settings and files
target MgreenNg (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C129ENCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MgreenNg +hex
  AfterMake: .\outputs\hex_crc.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: keil PART_TM4C129ENCPDT TARGET_IS_TM4C129_RA0 FREE_RTOS HW_UART
  c misc: --C99
  c include: ..\mgreen_2020;.\Application;.\driverlib;.\driverlib\inc;.\FreeRTOS;.\FreeRTOS\Source\include;.\FreeRTOS\Source\portable\RVDS\ARM_CM4F;.\BSP;.\Debug;.\Storage;.\SD_manager;.\Params;.\wdt;.\error_handler;.\digital_input;.\CAN;.\hardware_communication;.\relay;.\sensor;.\RF;.\CAN\can_api;.\CAN\can_parser;.\CAN\can_process;.\CAN\can_app;.\EEPROM;.\digital_input;.\mqtt;.\Utils;.\GSM;.\manual_control;.\Device;.\PortsControl;.\Display;.\Utils;.\FOTA;.\irrigation;.\schedule;..\mgreen-ng
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0xf0000
  memory RVCT6: RAM 0x61f00000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x3ffd0
  memory RVCT10: RAM 0x2003ffd0 size 0x48
  group main
    ./Application/: main.c
    ./: config.h
  group FreeRTOS
    ./FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group BSP
    ./BSP/: can_drv.c HAL_BSP.c rtc.c sdram.c sdram_utils.c
  group Driverlib
    ./driverlib/inc/: driverlib.lib
  group Debug
    ./Debug/: HardFault_debug.c act_log.c
  group SD_manage
    ./Storage/: ff.c libcsv.c mmc-dk-tm4c129x.c sd_card.c Storage.c
    ./SD_manager/: sd_manage_lib.c sd_app.c sd_manage_lib.h
  group Doxygen_template
    ./template/: header_template.h c_template.c
  group Digital_input
    ./digital_input/: digital_input.c
  group CAN
    ./CAN/can_api/: can_api.c
    ./CAN/can_parser/: can_parser.c
    ./CAN/can_process/: can_process.c
    ./CAN/: CAN_task.c CAN_task.h
  group Hardware_communication
    ./hardware_communication/: soft_SPI.c I2Clib.c i2c_mgreen.c spi_mgreen.c
  group Relay
    ./relay/: MCP23017.c relay_control.c
  group Sensor
    ./sensor/: pHEC.c sensor.c
  group RF
    ./RF/: cc1310.c lora.c rf.c
  group Error_handler
    ./error_handler/: error_handler.c
  group Wdt
    ./wdt/: wdt.c
  group MQTT
    ./mqtt/: frame_parser.c mqtt_publish.c mqtt_callbacks.c
    ./MQTT/: mqtt_task.c
  group Utils
    ./Utils/: uartstdio.c ustdlib.c mgreen_timeout.c i2c_lcd.c
  group GSM
    ./GSM/: gsm_hal.c gsm_cmd.c gsm_resp_task.c gsm_check_at.c
  group Params
    ./Params/: crc32.c params.c setting.c
  group EEPROM
    ./EEPROM/: eeprom_manage.c
  group FOTA
    ./FOTA/: hex_processing.c loader.c download.c download.h
  group Device
    ./Device/: device_setting.c
  group PortsControl
    ./PortsControl/: manual.c neutralize.c ports_control.c schedule.c threshold.c vpd_control.c
  group Display
    ./Display/: display_task.c
  group Schedule
    ./schedule/: schedule_parser.c schedule_task.c
  group Irrigation
    ./irrigation/: irrigation.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0
